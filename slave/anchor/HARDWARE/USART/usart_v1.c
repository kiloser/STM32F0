#include "usart_v1.h"
#include "stdio.h"
#include "sys.h"
uint8_t  USART_RX_BUF[USART_REC_LEN]; //接收缓冲,最大USART_REC_LEN个字节.末字节为换行符 
uint16_t USART_RX_STA; //接收状态标记
extern uint8_t usart_rx_buff[64];
extern usart_bitfield USART_STA;
uint8_t Res_in;

//void USART1_IRQHandler(void)
//{
//  if(USART_GetITStatus(USART1, USART_IT_RXNE) != RESET)
//  {
//    /* Read one byte from the receive data register */
//    RxBuffer[RxCount++] = (USART_ReceiveData(USART1) & 0x7F);

//    if(RxCount == NbrOfDataToRead)
//    {
//      /* Disable the USART1 Receive interrupt */
//      USART_ITConfig(USART1, USART_IT_RXNE, DISABLE);
//    }
//  }

//  if(USART_GetITStatus(USART1, USART_IT_TXE) != RESET)
//  {   
//    /* Write one byte to the transmit data register */
//    USART_SendData(USART1, TxBuffer[TxCount++]);

//    if(TxCount == NbrOfDataToTransfer)
//    {
//      /* Disable the USART1 Transmit interrupt */
//      USART_ITConfig(USART1, USART_IT_TXE, DISABLE);
//    }
//  }
//}
void USART1_IRQHandler(void)                	//串口1中断服务程序
{
	uint8_t Res;
	if(USART_GetITStatus(USART1, USART_IT_RXNE) != RESET)  //接收中断(接收到的数据必须是0x0d 0x0a结尾)
	{
		Res=USART_ReceiveData(USART1);
		usart_rx_buff[USART_STA.count]=Res;
	 if(usart_rx_buff[0]==0xFB)
	 {
		if(USART_STA.count==0)
		{
			USART_STA.count=(0xFB!=Res)?0:USART_STA.count+1;
		}
		else if(USART_STA.count==1)
		{
			USART_STA.count=(0xFB!=Res)?0:USART_STA.count+1;
		}
		else if(USART_STA.count==2)
		{
			USART_STA.count++;
		}
		else if(USART_STA.count>2)
		{
			USART_STA.count++;
			if(USART_STA.count==5+usart_rx_buff[2])
			{
				USART_STA.RC=1;				
			}
			else if(USART_STA.count>63)        //(USART_REC_LEN-1)
			{
				USART_STA.count=0;
				USART_STA.RC=0;
			}
		}
	 }
   else
	 {
		if((USART_RX_STA&0x8000)==0)//接收未完成
		{
			if(USART_RX_STA&0x4000)//接收到了0x0d
			{
				if(Res!=0x0a)USART_RX_STA=0;//接收错误,重新开始
				else USART_RX_STA|=0x8000;	//接收完成了 
			}
			else //还没收到0X0D
			{	
				if(Res==0x0d)USART_RX_STA|=0x4000;
				else
				{
					USART_RX_BUF[USART_RX_STA&0X3FFF]=Res ;
					USART_RX_STA++;
					if(USART_RX_STA>(USART_REC_LEN-1))USART_RX_STA=0;//接收数据错误,重新开始接收	  
				}		 
			}
		}
	 }
  } 			
} 



void USART_Config(void)
{ 
  USART_InitTypeDef USART_InitStructure;
  GPIO_InitTypeDef GPIO_InitStructure;
	NVIC_InitTypeDef NVIC_InitStructure;
  /* Enable GPIO clock */
  RCC_AHBPeriphClockCmd(RCC_AHBPeriph_GPIOA, ENABLE);

  /* Enable USART clock */
  RCC_APB2PeriphClockCmd(RCC_APB2Periph_USART1, ENABLE); 

  /* Connect PXx to USARTx_Tx */
  GPIO_PinAFConfig(GPIOA, GPIO_PinSource9, GPIO_AF_1);

  /* Connect PXx to USARTx_Rx */
  GPIO_PinAFConfig(GPIOA, GPIO_PinSource10, GPIO_AF_1);
  
  GPIO_InitStructure.GPIO_Pin = GPIO_Pin_9;
  GPIO_InitStructure.GPIO_Mode = GPIO_Mode_AF;
  GPIO_InitStructure.GPIO_Speed = GPIO_Speed_10MHz;
  GPIO_InitStructure.GPIO_OType = GPIO_OType_PP;
  GPIO_InitStructure.GPIO_PuPd = GPIO_PuPd_UP;
  GPIO_Init(GPIOA, &GPIO_InitStructure);
	
	
   
  GPIO_InitStructure.GPIO_Pin = GPIO_Pin_10;
  GPIO_Init(GPIOA, &GPIO_InitStructure);
  /* USARTx configured as follow:
  - BaudRate = 115200 baud  
  - Word Length = 8 Bits
  - Stop Bit = 1 Stop Bit
  - Parity = No Parity
  - Hardware flow control disabled (RTS and CTS signals)
  - Receive and transmit enabled
  */
  USART_InitStructure.USART_BaudRate = 115200;
  USART_InitStructure.USART_WordLength = USART_WordLength_8b;
  USART_InitStructure.USART_StopBits = USART_StopBits_1;
  USART_InitStructure.USART_Parity = USART_Parity_No;
  USART_InitStructure.USART_HardwareFlowControl = USART_HardwareFlowControl_None;
  USART_InitStructure.USART_Mode = USART_Mode_Rx | USART_Mode_Tx;
  USART_Init(USART1, &USART_InitStructure);
	
	USART_ClearFlag(USART1, USART_IT_RXNE);
	USART_ITConfig(USART1,USART_IT_RXNE, ENABLE); 
  USART_Cmd(USART1, ENABLE);
	
	NVIC_InitStructure.NVIC_IRQChannel = USART1_IRQn;
	NVIC_InitStructure.NVIC_IRQChannelPriority = 1;
	NVIC_InitStructure.NVIC_IRQChannelCmd = ENABLE;
	NVIC_Init(&NVIC_InitStructure);
}

#if 0
#pragma import(__use_no_semihosting)             
////标准库需要的支持函数                 
struct __FILE 
{ 
	int handle; 

}; 

FILE __stdout;       
//定义_sys_exit()以避免使用半主机模式    
_sys_exit(int x) 
{ 
	x = x; 
} 
//重定义fputc函数 
int fputc(int ch, FILE *f)
{      
	while(USART_GetFlagStatus(USART1,USART_FLAG_TC)==RESET); 
   USART_SendData(USART1,(uint8_t)ch);   
	return ch;
}
#endif 
int fputc(int ch, FILE *f)
{
	while(USART_GetFlagStatus(USART1,USART_FLAG_TC)==RESET); 
   USART_SendData(USART1,(uint8_t)ch); 	
   
    return ch;
}

